# Keil uVision project EcoLight_Maestro.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: EcoLight_Maestro +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s ADC2.c keypad.c LCD2.c RTC2.c interrupt2.c delay2.c main2.c keypad_main.c dummy.c
